## drivers/input/fpc1020/Kconfig
```kconfig
config INPUT_FPC1020
	tristate "fpc1020 driver support"
        depends on SPI_MASTER
	help
	  Say Y here if you want to support pfc1020 etc...
```
